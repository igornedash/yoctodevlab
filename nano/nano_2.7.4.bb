include nano.inc

SRC_URI[md5sum] = "e3a6b2740eb31f8a06d585f44d883895"
SRC_URI[sha256sum] = "23ffc2de52d687739fed6dc2fc94df36aa7da7bb52c8740c523fdd7336fdbc8c"
